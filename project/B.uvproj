# Keil uVision project B.uvproj, settings and files
target 室内外温控风扇 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: B +hex
  c flags: Optimize=8 SizeSpeed=1
  group app
    ../source/: Text1.c
  group bsp
    ../source/: anjian.c delay.c lanya.c lcd1602.c EEPROM.c ds18b20.c
